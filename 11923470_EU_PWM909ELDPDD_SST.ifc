Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-08-04T12:58:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 04 12:58:03 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\73f7099e-db9a-4115-acd4-ad45e5e99293\ab9e871c-b535-49fa-b551-0e23d4b7635e\ifc * Database version: 5507 * Database creation date: Thu Aug 04 12:58:03 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 04 12:58:03 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 04 12:58:03 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11923470_EU_PWM909ELDPDD_SST:51909004_EU_11923470_PWM909ELDPDD_SST, (2)
In: Default
Type - Material: z_Miele_Design_Stainless_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 51909004_EU_11923470_PWM909ELDPDD_SST
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 51909004_EU_11923470_PWM909ELDPDD_SST
Material: z_Miele_Design_Stainless_Steel, z_Miele_Design_Glass, z_Miele_Design_Steel_Chrom, z_Miele_Design_Glass Black, z_Miele_Design_CLST, Default, z_Miele_Connection_Water_OUT, z_Miele_Connection_Liquid Detergent, z_Miele_Connection_Water_IN, z_Miele_Connection_Network, z_Miele_Connection_Electric, z_Miele_Design_Iron_Grey, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - sets with these values: 2
